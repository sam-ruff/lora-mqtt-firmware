## bootloader/sdkconfig.defaults
```kconfig
# Silent bootloader configuration
CONFIG_BOOTLOADER_LOG_LEVEL_NONE=y
CONFIG_BOOTLOADER_LOG_LEVEL=0
```
